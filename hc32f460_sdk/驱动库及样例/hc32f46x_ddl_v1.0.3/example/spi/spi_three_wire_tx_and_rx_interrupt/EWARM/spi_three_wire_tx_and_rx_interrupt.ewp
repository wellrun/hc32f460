# IAR project spi_three_wire_tx_and_rx_interrupt.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_three_wire_tx_and_rx_interrupt.srec
  ILINK.IlinkOutputFile: spi_three_wire_tx_and_rx_interrupt.out
  ILINK.IlinkIcfFile: hc32f46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f46x.c
    ./: startup_hc32f46x.s
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_spi.c
  group source
    ../source/: main.c
