# IAR project usbh_msc.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F46x; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\fs\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\host_core; ..\..\..\..\usb_lib\host_class\msc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usbh_msc.srec
  ILINK.IlinkOutputFile: usbh_msc.out
  ILINK.IlinkIcfFile: hc32f46x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\fs\inc; ..\..\..\..\usb_lib\ctl_drv; ..\..\..\..\usb_lib\host_core; ..\..\..\..\usb_lib\host_class\msc; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f46x.c
    ./: startup_hc32f46x.s
  group driver
    ../../../../driver/src/: hc32f46x_icg.c hc32f46x_utility.c hc32f46x_clk.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c
  group usb_lib/ctl_drv
    ../../../../usb_lib/ctl_drv/: usb_core.c usb_otg.c usb_hcd.c usb_hcd_int.c
  group usb_lib/host_core
    ../../../../usb_lib/host_core/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group usb_lib/host_class
    ../../../../usb_lib/host_class/msc/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group midware/fs
    ../../../../midware/fs/src/: fattime.c ff.c
  group source
    ../source/: main.c usbh_usr.c usb_bsp_template.c
